#include<pic.h>
main()
{
#asm 
        CLRF   _STATUS,F
		BTFSC  30H,7
		GOTO   LOOP1
		GOTO	LOOP2
LOOP1:	COMF	30H,F
		INCF	30H,F
		BSF	30H,7
LOOP2:	BTFSC  31H,7
		GOTO   LOOP4
		GOTO	LOOP3 
LOOP4:	COMF	31H,F
		INCF	31H,F
		BSF	31H,7
LOOP3:	MOVF	30H,W
		ADDWF 31H,F
		BTFSC	31H,7
		GOTO	LOOP5
		GOTO	LOOP6
LOOP5:	COMF	31H,F
		INCF	31H,F
		BSF	31H,7
LOOP6:	MOVF	31H,W
		MOVWF 32H
#endasm 

loop:goto	loop;

}
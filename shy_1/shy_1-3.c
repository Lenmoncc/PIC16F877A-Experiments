#include<pic.h>
main()
{
#asm 
        CLRF   _STATUS,F
		BSF _STATUS ,5
		BCF _STATUS ,6 
		BTFSC  0E8H,7
		GOTO   LOOP1
		GOTO	LOOP2
LOOP1:	COMF	0E8H,F
		INCF	0E8H,F
		BSF	0E8H,7
LOOP2:	BTFSC  0E9H,7
		GOTO   LOOP4
		GOTO	LOOP3 
LOOP4:	COMF	0E9H,F
		INCF	0E9H,F
		BSF	0E9H,7
LOOP3:	MOVF	0E8H,W
		ADDWF 0E9H,F
		BTFSC	0E9H,7
		GOTO	LOOP5
		GOTO	LOOP6
LOOP5:	COMF	0E9H,F
		INCF	0E9H,F
		BSF	0E9H,7
LOOP6:	
		BSF _STATUS ,5
		BCF _STATUS ,6 
		MOVF	0E9H,W
		BCF _STATUS ,5
		BCF _STATUS ,5 
		MOVWF 32H
#endasm 
loop:goto	loop;

}